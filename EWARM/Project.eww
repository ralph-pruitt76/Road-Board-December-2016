<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Road Board Rev K NUCLEO V1.1 Jul 12 2016.ewp</path>
  </project>
  <batchBuild />
</workspace>

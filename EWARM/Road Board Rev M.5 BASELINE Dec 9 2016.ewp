# IAR project Road Board Rev M.5 BASELINE Dec 9 2016.ewp, settings and files
configuration Road Brd MSTR Rev L Long Always (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152VE ST STM32L152VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; ASCII; REV_L; LONG_DELAY
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32L1xx_Nucleo; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ..\Middlewares\Third_Party\BgLib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: Road Board Rev M.5 BASELINE Dec 9 2016.srec
  ILINK.IlinkOutputFile: Road Board Rev K NUCLEO V1.1 Jul 12 2016.out
  ILINK.IlinkIcfFile: stm32l152xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Road Brd MSTR Rev L Long (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32L1xx_Nucleo; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; D:\GoogleDriveCLT\GoogleDrive\WeatherCloud\Roadboard\Software\Road Board Rev L BASELINE Sept 26 2016\Middlewares\Third_Party\BgLib
configuration Road Brd MSTR Rev L (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; ASCII; REV_L
  ICCARM.CCIncludePath2: as above
configuration Road Brd MSTR Rev M LEGACY (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; ASCII; REV_L; LEGACY_PATCH
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Project.srec
configuration Road Brd MSTR Rev L PATCH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; ASCII; REV_L; PATCH_UART
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Road Brd MSTR COM Test Rev L (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; TEST2; REV_L; ASCII; PATCH_UART
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/BSP/STM32L1xx_Nucleo; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Road Brd Grid Eye (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; ASCII
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Road Brd Grid Eye COM Test (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; TEST2; ASCII
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Road Board Rev K NUCLEO V1.1 Jul 12 2016 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; NUCLEO
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Nucleo Board (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; NUCLEO; ASCII
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Road Brd Grid Eye TEST (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; TEST
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Nucleo Board TEST (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; NUCLEO; TEST
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
configuration Nucleo Board COM Test (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZE ST STM32L152ZE
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xE; USE_STM32L1XX_NUCLEO; NUCLEO; TEST2
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Project.srec
  group Application/EWARM
    ../Src/: adc.c
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l152xe.s
  group Application/User
    ../Src/: app_data.c barometer.c bgm111.c Calibration.c dma.c ErrorCodes.c fix_fft.c Flash.c freertos.c gpio.c GridEye.c Humidity.c i2c.c lps25hb.c main.c parser.c Rd_Sound.c RGBLight.c stm32l1xx_hal_msp.c stm32l1xx_hal_timebase_TIM.c stm32l1xx_it.c Temperature.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c VMonitor.c wwdg.c
  group Drivers/BSP/STM32L1xx_Nucleo
    ../Drivers/BSP/STM32L1xx_Nucleo/: stm32l1xx_nucleo.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_i2c.c stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_wwdg.c
  group Middlewares/BGLib
    ../Middlewares/Third_Party/BgLib/: gecko_bglib.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
